# Keil uVision project GD32_FreeRTOS_templete.uvprojx, settings and files
target ARM AC6 (6210000::V6.21::ARMCLANG)
  device: GD32F310F8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32_FreeRTOS_templete
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F310,PRINTF_INCLUDE_CONFIG_H
  c include: ..\..\Source\BSP\inc;..\..\Source\Config;..\..\Source\Core;..\..\Source\Drivers\CMSIS;..\..\Source\Drivers\CMSIS\GD\GD32F3x0\Include;..\..\Source\Drivers\GD32F3x0_standard_peripheral\Include;..\..\Source\Drivers\RTT;..\..\Source\Middlewares\FreeRTOS\Source\include;..\..\Source\Middlewares\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\Source\Retarget\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Core
    ../../Source/Core/: freertos.c gd32f3x0_it.c main.c
  group BSP
    ../../Source/BSP/src/: bsp_log.c bsp_systick.c bsp_timebase.c bsp_uart.c
  group Drivers/CMSIS
    ../../Source/Drivers/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
    ../../Source/Drivers/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group Drivers/GD32F3x0_standard_peripheral
    ../../Source/Drivers/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Drivers/RTT
    ../../Source/Drivers/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group FreeRTOS
    ../../Source/Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Source/Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Source/Middlewares/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Retarget
    ../../Source/Retarget/src/: printf.c scanf.c
